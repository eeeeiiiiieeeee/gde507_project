# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: GPIO
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER
  c include: D:\keil_pack\mdk_v5\pack\ARM\CMSIS\5.5.1\CMSIS\Include;..\application;..\CMSIS;..\CMSIS\GD\GD32E50x\Include;..\FWLIB\Include;..\Utilities;..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s
  group FWLIB
    ../FWLIB/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Utilities
    ../Utilities/: gd32e507z_eval.c
  group application
    ../application/: main.c PWM.c PWM.h
  group system
    ../system/: gd32e50x_it.c systick.c
